# Keil uVision project STM32-DEMO.uvproj, settings and files
target ADC1-DEMO (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-DEMO +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, NDEBUG
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src;..\Cunit\Headers;..\Cunit\Sources;..\Cunit\Sources\Automated;..\Cunit\Sources\Basic;..\Cunit\Sources\Console;..\Cunit\Sources\Curses;..\Cunit\Sources\Framework;..\Cunit\Sources\Test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c usart1.c
  group FWlib
    ../FWlib/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Cunit
    ../Cunit/Sources/Basic/: Basic.c
    ../Cunit/Sources/Framework/: CUError.c MyMem.c TestDB.c TestRun.c Util.c
    ../Cunit/Sources/: Misc.c
